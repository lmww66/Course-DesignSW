# Keil uVision project c8t6_oled.uvprojx, settings and files
target c8t6_oled (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: c8t6_oled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;..\BSP\BEEP;..\BSP\LCD;..\BSP\LED;..\BSP\KEY;..\BSP\mpu6050;..\BSP\oledlib;..\BSP\mpu6050\eMPL;..\BSP;..\Users\MYAPP;..\Users\Watch;..\Users;..\SYSTEM
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c
    ../Core/Src/: usart.c
  group Users
    ../Users/MYAPP/: My_Menu.c wait_data_clock.c
    ../Users/Watch/: sleep.c alarm.c alarms.c animation.c appconfig.c diag.c display.c draw.c game1.c game2.c game3.c games.c global.c m_display.c m_main.c menu.c millis.c normal.c pwrmgr.c resources.c settings.c sound.c stopwatch.c time.c timedate.c tones_data.c torch.c tune.c tunemaker.c tunes.c ui.c watch_init.c
    ../BSP/KEY/: buttons.c
  group BSP
    ../BSP/oledlib/: oled_basic.c oled_bmp.c oled_buffer.c oled_color.c oled_config.c oled_debug.c oled_draw.c oled_draw_ex_example.c oled_driver.c oled_font.c test.c
    ../BSP/mpu6050/: mpu_task.c mpu6050.c mpuiic.c
    ../BSP/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BSP/LED/: led.c
    ../BSP/LCD/: lcd.c
    ../BSP/BEEP/: beep.c
software components: CMSIS:CORE 4.3.0
